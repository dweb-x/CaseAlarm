<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>Flash</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <group>
    <name>app</name>
    <group>
      <name>include</name>
      <file>
        <name>$PROJ_DIR$\include\lcdbuffer.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\include\message.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\include\status.h</name>
      </file>
    </group>
    <group>
      <name>src</name>
      <file>
        <name>$PROJ_DIR$\src\lcdbuffer.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\src\main.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\src\message.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\src\status.c</name>
      </file>
    </group>
  </group>
  <group>
    <name>bsp</name>
    <group>
      <name>include</name>
      <file>
        <name>$PROJ_DIR$\..\..\bsp\include\accelerometer.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\bsp\include\adc.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\bsp\include\board.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\bsp\include\bsp.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\bsp\include\buttons.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\bsp\include\delay.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\bsp\include\lcd.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\bsp\include\leds.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\bsp\include\potentiometer.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\bsp\include\timers.h</name>
      </file>
    </group>
    <group>
      <name>src</name>
      <group>
        <name>lcd</name>
        <group>
          <name>fonts</name>
          <file>
            <name>$PROJ_DIR$\..\..\bsp\src\lcd\fonts\Terminal_9_12x6.c</name>
          </file>
        </group>
        <file>
          <name>$PROJ_DIR$\..\..\bsp\src\lcd\drv_glcd.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\bsp\src\lcd\glcd_ll.c</name>
        </file>
      </group>
      <file>
        <name>$PROJ_DIR$\..\..\bsp\src\accelerometer.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\bsp\src\adc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\bsp\src\bsp.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\bsp\src\buttons.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\bsp\src\delay.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\bsp\src\lcd.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\bsp\src\leds.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\bsp\src\potentiometer.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\bsp\src\timers.c</name>
      </file>
    </group>
  </group>
  <group>
    <name>Micrium</name>
    <group>
      <name>uC/CPU</name>
      <file>
        <name>$PROJ_DIR$\..\..\Micrium\Software\uC-CPU\ARM\IAR\cpu.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Micrium\Software\uC-CPU\ARM\IAR\cpu_a.s</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Micrium\Software\uC-CPU\cpu_def.h</name>
      </file>
    </group>
    <group>
      <name>uC/LIB</name>
      <file>
        <name>$PROJ_DIR$\..\..\Micrium\Software\uC-LIB\lib_def.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Micrium\Software\uC-LIB\lib_mem.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Micrium\Software\uC-LIB\lib_mem.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Micrium\Software\uC-LIB\lib_str.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Micrium\Software\uC-LIB\lib_str.h</name>
      </file>
    </group>
    <group>
      <name>uC/OS-II</name>
      <group>
        <name>Port</name>
        <file>
          <name>$PROJ_DIR$\..\..\Micrium\Software\uCOS-II\Ports\ARM\Generic\IAR\cstartup.s</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\Micrium\Software\uCOS-II\Ports\ARM\Generic\IAR\os_cpu.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\Micrium\Software\uCOS-II\Ports\ARM\Generic\IAR\os_cpu_a.asm</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\Micrium\Software\uCOS-II\Ports\ARM\Generic\IAR\os_cpu_c.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\Micrium\Software\uCOS-II\Ports\ARM\Generic\IAR\os_dbg.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\Micrium\Software\uCOS-II\Ports\ARM\Generic\IAR\os_dcc.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\Micrium\Software\uCOS-II\Ports\ARM\Generic\IAR\osutils.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\Micrium\Software\uCOS-II\Ports\ARM\Generic\IAR\osutils.h</name>
        </file>
      </group>
      <group>
        <name>Source</name>
        <file>
          <name>$PROJ_DIR$\..\..\Micrium\Software\uCOS-II\Source\os_core.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\Micrium\Software\uCOS-II\Source\os_flag.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\Micrium\Software\uCOS-II\Source\os_mbox.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\Micrium\Software\uCOS-II\Source\os_mem.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\Micrium\Software\uCOS-II\Source\os_mutex.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\Micrium\Software\uCOS-II\Source\os_q.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\Micrium\Software\uCOS-II\Source\os_sem.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\Micrium\Software\uCOS-II\Source\os_task.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\Micrium\Software\uCOS-II\Source\os_time.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\Micrium\Software\uCOS-II\Source\os_tmr.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\Micrium\Software\uCOS-II\Source\ucos_ii.h</name>
        </file>
      </group>
    </group>
  </group>
</project>


